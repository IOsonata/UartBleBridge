# IAR project Blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52832_xxAA NordicSemi nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NRF52832_XXAA
  ICCARM.CCIncludePath2: ..\src; ..\..\..\lib\include; ..\..\..\..\..\include; ..\..\..\..\..\..\include; ..\..\..\..\..\..\..\include; ..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\..\external\nRF5_SDK\modules\nrfx\mdk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Blinky.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Z:\swdev\IOsonata\ARM\Nordic\nRF52\nRF52832\ldscript\nrf52832_xxaa.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\lib\IAR\Debug\Exe\IOsonata_nRF52832.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group src
    ../../../../../../../exemples/misc/: blinky.c
    ../src/: board.h
